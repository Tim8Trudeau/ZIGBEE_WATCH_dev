# IAR project BarronWatch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FEATURE_RESET_MACRO; ewarm; NWK_AUTO_POLL; xPOWER_SAVING; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=NO; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: -f f8wConfig.cfg; -f f8wEndev.cfg
  ICCARM.CCIncludePath2: ..\Source; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Projects\zstack\ZMain\TI2538DB; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\hal\include; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\hal\target\CC2538; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\driverlib\cc2538\inc; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\driverlib\cc2538\source; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\bsp\srf06eb_cc2538\drivers\source; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\mac\include; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\mac\high_level; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\mac\low_level\srf05\single_chip; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\mac\low_level\srf05; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\mt; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\osal\include; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\services\sdata; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\services\saddr; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\stack\af; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\stack\nwk; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\stack\sapi; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\stack\sec; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\stack\sys; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\stack\zdo; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\zmac; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\zmac\f8w
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: BarronWatch.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\TexasInstruments\cx2538xf53.icf
  ILINK.IlinkAdditionalLibs: C:\Texas Instruments\Z-Stack Mesh 1.0.0\Projects\zstack\Libraries\CC2538\bin\EndDevice.a; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Projects\zstack\Libraries\TIMAC\bin\TIMAC-CC2538.a; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; C:\Texas Instruments\Z-Stack Mesh 1.0.0\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/stack/af/: AF.c
    ./: MainApplication.c OSAL_WatchApp.c SerialPorts.c WatchHW.c WatchInitStack.c
  group Application/Includes
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/stack/af/: AF.h
    ./: hal_board.h WatchApp.h WatchHW.h WatchInitStack.h
  group HAL
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/hal/target/CC2538/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_timer.c hal_uart.c startup_ewarm.c
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/hal/target/CC2538/New folder/: hal_aes.c hal_ccm.c hal_mac_cfg.c hal_sleep.c hal_sys_ctrl.c hal_systick.c
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/hal/common/: hal_assert.c hal_drivers.c
  group MAC
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/mac/low_level/srf05/: mac_autopend.c mac_backoff_timer.c mac_low_level.c mac_radio.c mac_rx.c mac_rx_onoff.c mac_sleep.c mac_tx.c
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/mac/high_level/: mac_cfg.c mac_pib.c
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/mac/low_level/srf05/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c mac_rffrontend.c
  group MT
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/mt/: DebugTrace.c MT.c MT_AF.c MT_APP.c MT_DEBUG.c MT_MAC.c MT_NWK.c MT_SAPI.c MT_SYS.c MT_TASK.c MT_UART.c MT_UTIL.c MT_VERSION.c MT_ZDO.c
  group NWK
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/stack/nwk/: BindingTable.c nwk_globals.c
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/stack/sys/: ZDiags.c ZGlobals.c
  group OSAL
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/osal/mcu/cc2538/: armcm3flashutil.c osal_nv.c
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Services
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/services/saddr/: saddr.c
  group ZDO
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/stack/zdo/: ZDApp.c ZDConfig.c ZDNwkMgr.c ZDObject.c ZDProfile.c ZDSecMgr.c
  group Zmac
    ../../../../../Texas Instruments/Z-Stack Mesh 1.0.0/Components/zmac/f8w/: zmac.c zmac_cb.c
