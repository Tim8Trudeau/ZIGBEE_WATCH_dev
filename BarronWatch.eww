<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BarronWatch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\Texas Instruments\Z-Stack Mesh 1.0.0\Projects\zstack\Samples\GenericApp\CC2538\GenericApp.ewp</path>
  </project>
  <batchBuild/>
</workspace>


